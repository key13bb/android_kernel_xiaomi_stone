## fs/susfs/Kconfig
```kconfig
config SUSFS
    bool "SUSFS support"
    default y
    help
      Simple Untrusted Storage Filesystem support.
```
